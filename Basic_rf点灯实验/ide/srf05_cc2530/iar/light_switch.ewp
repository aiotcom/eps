# IAR project light_switch.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/basicrf; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common/cc8051; ../../../source/Components/targets/srf05_soc; ../../../source/Components/radios/cc2530; ../../../source/apps/LED; ../../../source/apps/KEY; ../../../source/apps/Delay
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: C:\ZHY\8051\config\lnk51e.xcl
  group application
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/apps/Delay/: delay.c
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/apps/KEY/: KEY.c
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/apps/LED/: LED.c
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/apps/light_switch/: light_switch.c
  group basic rf
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group hal/common
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/common/cc8051/: hal_cc8051.h
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/common/: hal_defs.h hal_int.c hal_types.h
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/targets/common/: hal_lcd_srf05.c
  group hal/interface
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_joystick.h hal_lcd.h hal_led.h hal_mcu.h
  group hal/rf
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/targets/interface/: hal_rf.h hal_rf_security.h
  group hal/rf/cc2530
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/radios/cc2530/: adc.c adc.h clock.c clock.h hal_mcu.c hal_rf.c hal_rf_security.c
  group hal/srf05_soc
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_joystick.c hal_led.c
  group utilities
    $EW_DIR$/代码/aiotcode-master/多网融合实验装置/3.基于无线传感网络的实验/3.1无线点灯实验/source/Components/utils/: util.c util.h util_buffer.c util_buffer.h util_lcd.c util_lcd.h
