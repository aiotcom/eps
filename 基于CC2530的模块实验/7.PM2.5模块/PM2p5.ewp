# IAR project PM2p5.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: HARDWARE\DELAY; HARDWARE\OLED; HARDWARE\PM2p5; HARDWARE\OLEDIIC; $PROJ_DIR$; HARDWARE\USART
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group APP
    ./: main.c
  group HARDWARE
    HARDWARE/Delay/: delay.c delay.h
    HARDWARE/OLED/: OLED.c OLED.h
    HARDWARE/OLEDIIC/: OLEDIIC.c OLEDIIC.h
    HARDWARE/PM2p5/: PM2p5.c PM2p5.h
    HARDWARE/USART/: USART.c USART.h
